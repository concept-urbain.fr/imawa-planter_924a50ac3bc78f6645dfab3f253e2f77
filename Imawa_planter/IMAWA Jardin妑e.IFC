Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: IMAWA Jardinère.IFC
Time: 2020-07-03T11:35:20
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: IMAW-JAR-002_Avec assise
In: Default Storey
Material: PE haute densité
PSet_Mass_Property - Mass Measure: 78.0226; Area Measure: 19.7555; Volume Measure: 0.061263

# IfcBuildingElementProxy: IMAW-JAR-005_Default
In: Default Storey
Material: S235 galva

# IfcBuildingElementProxy: IMAW-JAR-006_Default
In: Default Storey
Material: Moabi

# IfcBuildingElementProxy: IMAW-JAR-007_Default
In: Default Storey
Material: S235 galva
